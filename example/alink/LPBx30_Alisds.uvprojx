# Keil uVision project LPBx30_Alisds.uvprojx, settings and files
target LPT230 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: LPBx30
  AfterMake: arm-none-eabi-objcopy -O binary ./LPBx30.elf ./LPBx30.bin
  AfterMake: ../../tools/LPB100_IMG_Tools.exe LPB230 lzma  ../../tools/bootloader.bin LPBx30.bin ./LPBx30_image.bin ./LPBx30_upgrade.bin
  group src
    ./: startup_LPBX3GCC.S alinktest.c
    ../../thirdpartylib/Alink/: alink_config.c
