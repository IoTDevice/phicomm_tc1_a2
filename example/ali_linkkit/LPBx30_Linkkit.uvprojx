# Keil uVision project LPBx30_Linkkit.uvprojx, settings and files
target LPT230 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: lpt230_linkkit
  AfterMake: ../../tools/arm-none-eabi-objcopy -O binary ./lpt230_linkkit.elf ./lpt230_linkkit.bin
  AfterMake: ../../tools/LPB100_IMG_Tools.exe LPB230 lzma  ../../tools/bootloader.bin lpt230_linkkit.bin ./lpt230_linkkit_image.bin ./lpt230_linkkit_upgrade.bin
  group src
    ../../sdk/4.13/libs/: startup_LPBX3GCC.S
    ../ali_linkkit/: linkkittest.c linkkit.c
