# Keil uVision project LPBx30_Linkkit_gcc.uvprojx, settings and files
target LPx30_Linkkit (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: LPBx30Linkkit (library)
  group ref-impl
    ../src/ref-impl/hal/: HAL_OS_HF.c HAL_TCP_HF.c
  group infra
    ../src/infra/system/: aos_support.c ca.c device.c event.c guider.c report.c
    ../src/infra/utils/digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c utils_sha256.c
    ../src/infra/utils/misc/: lite-cjson.c mem_stats.c string_utils.c utils_event.c utils_httpc.c utils_net.c utils_timer.c
    ../src/infra/log/: iotx_log.c
  group sdk-impl
    ../src/sdk-impl/: impl_dynreg.c impl_linkkit.c impl_logpost.c sdk-impl.c
  group services
    ../src/services/mdal/mal/ica/: mdal_ica_at_client.c
    ../src/services/mdal/mal/: mal.c
    ../src/services/linkkit/cm/: iotx_cm.c iotx_cm_coap.c iotx_cm_mqtt.c
    ../src/services/linkkit/dev_reset/: awss_reset.c
    ../src/services/linkkit/dm/client/: dm_client.c dm_client_adapter.c
    ../src/services/linkkit/dm/server/: dm_server.c dm_server_adapter.c
    ../src/services/linkkit/dm/: dm_api.c dm_cota.c dm_fota.c dm_ipc.c dm_manager.c dm_message.c dm_message_cache.c dm_msg_process.c dm_opt.c dm_ota.c dm_shadow.c dm_tsl_alink.c dm_utils.c
  group protocol
    ../src/protocol/mqtt/client/: mqtt_client.c
    ../src/protocol/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
